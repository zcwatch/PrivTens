# Keil uVision project privateTens.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: privateTens +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS;..\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS\GD\GD32F30x\Include;..\GD32F30x_Firmware_Library_V2.1.3\Firmware\GD32F30x_standard_peripheral\Include;..\source;..\tenslibs\include;..\eeprom_in_flash
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FWLib
    ../GD32F30x_Firmware_Library_V2.1.3/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_usart.c gd32f30x_timer.c gd32f30x_fmc.c gd32f30x_dma.c gd32f30x_fwdgt.c gd32f30x_dac.c gd32f30x_spi.c
  group CMSIS
    ../GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group HAL
    ../source/: hc595.c board.c btuart.c pwm.c
  group APP
    ../source/: main.c tens.c motortip.c button.c hv.c eepromemul.c lcd.c tensdata.c tensoutput.c battery.c heat.c vib.c lcdFont.c tensgui.c uidata.c rbuf.c therapy.c tensproto.c
    ../eeprom_in_flash/: eeprom_in_flash.c
    ../eeprom_in_flash/eeprom_port/: eeprom_port_gd32f1.c
  group presc
    ../tenslibs/src/: carrier.c prescdata.c prescoutput.c rtdataoutput.c
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: as above
  output: privateTens +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,RELEASE
  c include: ..\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS;..\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS\GD\GD32F30x\Include;..\GD32F30x_Firmware_Library_V2.1.3\Firmware\GD32F30x_standard_peripheral\Include;..\source;..\eeprom_in_flash;..\tenslibs\include
  memory RVCT4: ROM 0x8001800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
