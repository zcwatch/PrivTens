# Keil uVision project tens-bootloader.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tens-bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\GD32F30x_Firmware_Library_V2.1.3\Firmware\GD32F30x_standard_peripheral\Include;..\..\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS\GD\GD32F30x\Include;..\src;..\..\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FWLib
    ../../GD32F30x_Firmware_Library_V2.1.3/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c
  group CMSIS
    ../../GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../../GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group APP
    ../src/: main.c fw_data.c board.c
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: as above
  output: tens-bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,RELEASE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0xc000
